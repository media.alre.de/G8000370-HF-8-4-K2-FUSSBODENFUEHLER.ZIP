Properties of the parts of a building model (IFC2X3)

# File
Description: Hülsentemperaturfühler, NTC 2K, 4 m, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G8000370, Hülsentemperaturfühler, NTC 2K, 4 m
In: Raum
Description: Hülsentemperaturfühler, NTC2 K, 4 m, Material der Fühlerleitung PVC; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G8000370; ModelLabel: HF-8/4-K2; GlobalTradeItemNumber: 4050528035370; ProductURL: https://alre.de/produkt_G8000370
Pset_Specification - NominalLength: 0.6 m; NominalWidth: 0.0077 m; NominalDepth: 0.0077 m; NetWeight: 0.152
Pset_ALRE_ETIM_Properties - Kabellänge: 4; Art der Spannungsversorgung: ohne; Geeignet für Rohrmontage: yes; Umgebungstemperatur: -5; Explosionsgeschützt: no; Schutzart (IP): IP65; Mit Befestigungsmaterial: no; Einsatzgebiet: Tauchrohr/-kanal; Geeignet für Flüssigkeiten: yes; Geeignet für Gase: yes; Aktive Temperaturmessung: no; Passive Temperaturmessung: yes; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Durchmesser Sensorelement: 7.7; Einstecklänge: 28; Gehäusehöhe: 7.7; Gehäusebreite: 7.7; Gehäusetiefe: 600; Geeignet für Kanalbefestigung: yes; Festes Kabel am Sensor: yes; Länge des Sensors: 28; Geeignet für Luft: yes; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G8000370.pdf
